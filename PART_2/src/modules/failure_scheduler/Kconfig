## PART_2/src/modules/failure_scheduler/Kconfig
```kconfig
menuconfig MODULES_FAILURE_SCHEDULER
	bool "failure_scheduler"
	default n
	---help---
		Enable support for failure_scheduler
```
